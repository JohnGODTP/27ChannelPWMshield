# Keil uVision project MChPwm.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MChPwm +hex
  c flags: Optim=1
  c define: STM32F10X_MD        __NO_EMBEDDED_ASM
  c include: .\Header_Files;.\Header_Files\STM32F10x;.\Source_Files
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source_Files
    ./Source_Files/: delay.c spi.c startup_stm32f10x_md.s main.cpp pwm.cpp hardware_pwm.cpp pwm_top.cpp ring_buffer.cpp mscomm.cpp
  group Header_Files
    ./Header_Files/: delay.h pincfg.h spi.h typedef.h gpio.h pwm.h hardware_pwm.h pwm_top.h ring_buffer.h ring_buffer_def.h mscomm.h
